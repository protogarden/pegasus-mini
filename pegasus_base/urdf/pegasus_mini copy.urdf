Commit message: Fixes

File: pegasus_base/urdf/pegasus_mini copy.urdf (robot description, URDF)
Before this commit: robot pegasus_mini, 5 links, 4 joints
Links:
- link frontcastor: mass 0.232013920708616 -> None
